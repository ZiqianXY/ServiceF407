# Keil uVision project ObdServiceF407.uvprojx, settings and files
target F407-CAN-OBD (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: obdService407 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\FWLIB\inc;..\HARDWARE;..\SERVICE;..\MALLOC;..\FATFS\src;..\FATFS\exfuns;..\ESP8266;..\HARDWARE\new
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_fsmc.c stm32f4xx_tim.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FAFST
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/exfuns/: exfuns.c
  group HARDWARE
    ../HARDWARE/: beep.c can.c key.c led.c timer.c sdio_sdcard.c sram.c w25qxx.c spi.c rtc.c usart3.c
    ../HARDWARE/new/: 24cxx.c myiic.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SERVICE
    ../SERVICE/: database.c OBD.c zString.c
  group README
    ../: readme.txt
  group ESP8266
    ../ESP8266/: common.c wifista.c
  group new
    ../HARDWARE/new/: ctiic.c ft5206.c gt9147.c lcd.c ott2001a.c touch.c fontupd.c text.c
